# IAR project project.ewp, settings and files
configuration stm8l10x (STM8, debug)
  General.GenDeviceSelectMenu: STM8L001J3 STM8L001J3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..; G:\Embedded\STM8\IAR\STM8L001J3\STM8L10x_StdPeriph_Driver\inc; G:\Embedded\STM8\IAR\STM8L001J3
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: stm8l101-eval.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group StdPeriph_Drivers
    ../STM8L10x_StdPeriph_Driver/src/: stm8l10x_clk.c stm8l10x_exti.c stm8l10x_gpio.c stm8l10x_usart.c
  group User
    ../: delay.c main.c stm8l10x_conf.h stm8l10x_it.c tsic506.c usart.c
